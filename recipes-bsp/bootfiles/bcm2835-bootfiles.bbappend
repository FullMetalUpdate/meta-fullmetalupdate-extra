# Copyright (C) 2019 Witekio
# Released under the MIT license (see COPYING.MIT for the terms)
RDEPENDS_${PN}_append_sota += " u-boot-otascript"
