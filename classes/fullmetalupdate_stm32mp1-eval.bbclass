# Copyright (C) 2019 Witekio
# Released under the MIT license (see COPYING.MIT for the terms)

MACHINE_FEATURES = "gpu"
GCNANO_USERLAND_USE_VENDOR_DIR = "0"

