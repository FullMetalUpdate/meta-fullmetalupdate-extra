PREINSTALLED_CONTAINERS_LIST_append_imx6qdlsabresd = "container-qt-evcs-package"

PACKAGECONFIG_remove-pn-qtbase_imx6qdlsabresd = "x11 xcb xkb xkbcommon-evdev"

IMAGE_ROOTFS_EXTRA_SPACE_imx6qdlsabresd = "202173"
