# Copyright (C) 2019 Witekio
# Released under the MIT license (see COPYING.MIT for the terms)
require ${PN}_${MACHINE}.inc
