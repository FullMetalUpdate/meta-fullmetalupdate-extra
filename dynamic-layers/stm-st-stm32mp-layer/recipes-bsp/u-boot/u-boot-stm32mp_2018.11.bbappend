# Copyright (C) 2019 Witekio
# Released under the MIT license (see COPYING.MIT for the terms)
FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += " \
    file://0009-ARM-v2018.11-stm32mp-r1-CONFIG.patch \
    "